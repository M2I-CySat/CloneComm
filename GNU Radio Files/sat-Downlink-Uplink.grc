options:
  parameters:
    generate_options: no_gui
    id: sat_downlink_uplink
    output_language: python
    title: CloneComm
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '436375000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: fm_decimate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rr_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240385'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/cysat-radio/Desktop/CloneComm/SatLink/Packets/packets822.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/cysat-radio/Desktop/CloneComm/Newly_Generated_CySat_Packet_For_Uplink
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '19200'
    interp: '240385'
    type: ccc
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/cysat-radio/Desktop/CloneComm/SatLink/CYSAT.yml
    iq: 'True'
    name: GASPACS
    norad: '43199'
    samp_rate: samp_rate
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    start_time: '-2'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_1, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [satellites_satellite_decoder_0, out, network_socket_pdu_0, pdus]
- [satellites_satellite_decoder_0, out, pdu_pdu_to_stream_x_0, pdus]
- [uhd_usrp_sink_0, async_msgs, blocks_message_debug_0_0, print]
- [uhd_usrp_source_0, '0', satellites_satellite_decoder_0, '0']

metadata:
  file_format: 1
