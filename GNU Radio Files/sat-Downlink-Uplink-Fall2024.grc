options:
  parameters:
    generate_options: qt_gui
    id: sat_downlink_uplink_fall2024
    output_language: python
    title: CloneComm
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '436375000'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: fm_decimate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rr_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240385'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/groundstation/CloneComm/GNU Radio Files/Packets/packets822.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/groundstation/CloneComm/Newly_Generated_CySat_Packet_For_Uplink.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/groundstation/CloneComm/Newly_Generated_CySat_Packet_For_Uplink.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: ' pmt.cons(pmt.PMT_NIL, pmt.make_u8vector(16, 0xFF))'
    period: '10'
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5556'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_pdu_to_stream_x_1
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '19200'
    interp: '240385'
    type: ccc
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/groundstation/CloneComm/GNU Radio Files/CYSAT.yml
    iq: 'True'
    name: GASPACS
    norad: '43199'
    samp_rate: samp_rate
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_rate: 120e6
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    start_time: '-2'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_pub_msg_sink_2
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {state: disabled}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_file_source_0_0, '0', blocks_message_strobe_0, set_msg]
- [blocks_message_strobe_0, strobe, zeromq_pub_msg_sink_2, in]
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_1, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_pdu_to_stream_x_1, '0', digital_gfsk_mod_0, '0']
- [rational_resampler_xxx_1, '0', soapy_hackrf_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink_0, '0']
- [satellites_satellite_decoder_0, out, blocks_message_debug_0, print_pdu]
- [satellites_satellite_decoder_0, out, network_socket_pdu_0, pdus]
- [satellites_satellite_decoder_0, out, pdu_pdu_to_stream_x_0, pdus]
- [satellites_satellite_decoder_0, out, zeromq_pub_msg_sink_0, in]
- [soapy_hackrf_source_0, '0', satellites_satellite_decoder_0, '0']
- [uhd_usrp_sink_0, async_msgs, blocks_message_debug_0_0, print]
- [uhd_usrp_source_0, '0', satellites_satellite_decoder_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0_0_0, print]
- [zeromq_sub_msg_source_0, out, pdu_pdu_to_stream_x_1, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
