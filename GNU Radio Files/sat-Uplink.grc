options:
  parameters:
    generate_options: qt_gui
    id: sat_tx
    output_language: python
    title: Groundstation Transmit
  states: {}

blocks:
- name: RF_Center_Freq
  id: variable
  parameters:
    value: '436375000'
  states: {}
- name: TX_samp_rate
  id: variable
  parameters:
    value: int(iq_file_samp_rate * interpolation / decimation)
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '6'
  states: {}
- name: iq_file_samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: variable_qtgui_range_1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '32000'
    value: '40'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/groundstation/CloneComm/Newly_Generated_CySat_Packet_For_Uplink.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: samp_per_symbol
    sensitivity: '1.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: variable_qtgui_range_1
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '19200'
    interp: '240385'
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: RF_Center_Freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: RF_Center_Freq
    gain0: '30'
    samp_rate: '240385'
    start_time: '-2'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', soapy_hackrf_sink_0, '0']
- [rational_resampler_xxx_1, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_sink_0, async_msgs, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
